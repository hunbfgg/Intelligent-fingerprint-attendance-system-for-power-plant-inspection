# Keil uVision project ATK_ESP8266.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ATK_ESP8266 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\ATK-ESP8266;..\CORE;..\FATFS\src;..\FATFS\exfuns;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\SDIO;..\HARDWARE\SPI;..\HARDWARE\TIMER;..\HARDWARE\TOUCH;..\HARDWARE\USART3;..\HARDWARE\W25QXX;..\MALLOC;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\TEXT;..\USER;..\USMART;..\HARDWARE\USART2;..\HARDWARE\AS608;..\HARDWARE\key1;..\HARDWARE\RTC;..\HARDWARE\SQL;..\HARDWARE\BEEP;..\HARDWARE\EZIO;..\HARDWARE\IO_IIC;..\HARDWARE\IO_SPI;..\HARDWARE\TEXT;..\HARDWARE\Administrators;..\HARDWARE\STMFLASH;..\CJSON;..\MQTT
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/TOUCH/: ctiic.c touch.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/AS608/: as608.c
    ../HARDWARE/key1/: key1.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/SQL/: sql.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/EZIO/: ezio.c
    ../HARDWARE/IO_IIC/: ioiic.c
    ../HARDWARE/IO_SPI/: iospi.c
    ../HARDWARE/Administrators/: admin.c
    ../HARDWARE/STMFLASH/: stmflash.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_bkp.c stm32f10x_flash.c
  group MALLOC
    ../MALLOC/: malloc.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group ATK_ESP8266
    ../ATK-ESP8266/: apsta.c common.c wifiap.c wifista.c
  group README
    ../: README.TXT process.txt
  group FAFTS
    ../FATFS/: fattester.c
    ../FATFS/src/: ff.c diskio.c
    ../FATFS/exfuns/: exfuns.c
    ../FATFS/src/option/: cc936.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group cJSON
    ../CJSON/: cJSON.c
  group MQTT
    ../MQTT/: transport.c MQTTUnsubscribeServer.c MQTTUnsubscribeClient.c MQTTSubscribeServer.c MQTTSubscribeClient.c MQTTSerializePublish.c MQTTPacket.c MQTTFormat.c MQTTDeserializePublish.c MQTTConnectServer.c MQTTConnectClient.c MQTT.c
